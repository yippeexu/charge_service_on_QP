# Keil uVision project charge_service.uvproj, settings and files
target spy (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: charge_service +hex
  BeforeMake: cmd /c "del .\Objects\qstamp.o"
  AfterMake: fromelf --bin --output .\Objects\charge_service.bin .\Objects\charge_service.axf
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: HSE_VALUE=4000000 USE_STDPERIPH_DRIVER Q_SPY STM32F10X
  c include: .\CMSIS\4.2.0\CMSIS\Include;.\QP\include;.\QP\src;.\QP_port\arm-cm\qv\arm;.\STM32F1xx_DFP\2.0.0\Device\Include;.\STM32F1xx_DFP\2.0.0\Device\StdPeriph_Driver\inc;.\STM32F1xx_DFP\2.0.0\Device\StdPeriph_Driver\templates;.\user;.\user\common;.\user\xd;.\user\security
  asm define: Stack_Size=1024 Heap_Size=4096
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group user
    ./user/: main.c bsp.c module.c module_rx.c system.c bsp_usart.c l206.c http.c battery.c
  group STM32F1xx_DFP
    ./STM32F1xx_DFP/2.0.0/Device/Source/: system_stm32f10x.c
    ./STM32F1xx_DFP/2.0.0/Device/StdPeriph_Driver/src/: stm32f10x_crc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c
    ./STM32F1xx_DFP/2.0.0/Device/StdPeriph_Driver/templates/: stm32f10x_conf.h
    ./STM32F1xx_DFP/2.0.0/Device/Source/ARM/: startup_stm32f10x_hd.s
  group QP
    ./QP/src/qf/: qep_hsm.c qep_msm.c qf_act.c qf_actq.c qf_defer.c qf_dyn.c qf_mem.c qf_ps.c qf_qact.c qf_qeq.c qf_qmact.c qf_time.c
    ./QP/src/qv/: qv.c
  group QP_port
    ./QP_port/arm-cm/qv/arm/: qep_port.h qf_port.h qs_port.h qv_port.c qv_port.h
  group QS
    ./QP/src/qs/: qs.c qs_64bit.c qs_fp.c
    ./QP/src/: qs_pkg.h
    ./QP/include/: qstamp.c
  group common
    ./user/common/: fifo.c string_tool.c cJSON.c
  group xd
    ./user/xd/: xd_time.c xd_flash.c
  group security
    ./user/security/: aes.c base64.c md5.c
